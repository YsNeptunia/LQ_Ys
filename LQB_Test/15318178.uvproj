# Keil uVision project 15318178.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15F2K60S2 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: 15318178 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 main.c
  group System
    ./: Timer.c Device.c iic.c onewire.c
  group Hardware
    ./: KBD.c SEG.c ds1302.c DS18B20.c ADDA.c EEPROM.c Usonic.c
