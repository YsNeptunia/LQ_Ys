# Keil uVision project 14338009.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC12C5A60S2 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x3FF) IROM(0-0xEFFF) CLOCK(45000000) MODP2
  output: 14338009 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 main.c
  group System
    ./: Timer.c Device.c iic.c
  group Hardware
    ./: KBD.c SEG.c ADDA.c USonic.c
