# Keil uVision project LQ_Ys.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15F2K60S2 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: LQ_Ys +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 main.c
  group System
    ./: Timer.c Device.c iic.c onewire.c
  group Hardware
    ./: SEG.c KBD.c Ds1302.c ADDA.c Ds18B20.c
