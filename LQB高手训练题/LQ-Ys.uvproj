# Keil uVision project LQ-Ys.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15F2K60S2 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: LQ-Ys +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 main.c
  group System
    ./: Device.c Timer.c iic.c onewire.c Uart.c
  group Device
    ./: ds1302.c KBD.c SEG.c Ultra.c ADDA.c DS18B20.c EEPROM.c
