# Keil uVision project LQ-Ys.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15F2K60S2 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: LQ-Ys +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 main.c
  group System
    ./: Timer.c Device.c onewire.c
  group Hardware
    ./: KBD.c SEG.c DS1302.c DS18B20.c
